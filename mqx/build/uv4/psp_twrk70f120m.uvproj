# Keil uVision project psp_twrk70f120m.uvproj, settings and files
target psp_twrk70f120m Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: psp_twrk70f120m_d (library)
  AfterMake: ..\bat\psp_twrk70f120m.bat ..\..\..\lib\twrk70f120m.uv4\psp uv4 debug twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c include: ..\..\..\config\common;..\..\..\config\twrk70f120m;..\..\source\io\pcb;..\..\source\io\pcb\mqxa;..\..\source\tad;..\..\source\psp\cortex;..\..\source\include;..
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
  group twrk70f120m User Config
    ../../../config/twrk70f120m/: user_config.h
  group PSP Generic:event
    ../../../mqx/source/event/: ev_all.c ev_allf.c ev_allt.c ev_allu.c ev_any.c ev_anyf.c ev_anyt.c ev_anyu.c ev_clear.c ev_close.c ev_comp.c ev_creaa.c ev_creai.c ev_creat.c ev_dest.c ev_fcrt.c ev_fcrta.c ev_fcrti.c ev_fdest.c ev_fopn.c ev_open.c ev_set.c ev_tdel.c ev_test.c ev_util.c ev_waiti.c
  group PSP Generic:fio
    ../../../mqx/source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group PSP Generic:io
    ../../../mqx/source/io/: io_ghand.c io_init.c io_inst.c io_instx.c io_shand.c io_uinst.c
  group PSP Generic:ipc
    ../../../mqx/source/ipc/: ipc_add.c ipc_adio.c ipc_evnt.c ipc_pcb.c ipc_rout.c ipc_rtt.c ipc_task.c
  group PSP Generic:kernel
    ../../../mqx/source/kernel/: idletask.c int_dep.c int_disa.c int_ena.c int_gdat.c int_gdef.c int_geh.c int_gisr.c int_idef.c int_iisr.c int_init.c int_isr.c int_iunx.c int_ixcp.c int_sdat.c int_seh.c lws_crea.c lws_dest.c lws_poll.c lws_post.c lws_test.c lws_wafo.c lws_wain.c lws_wait.c lws_wati.c lws_waun.c mem_alli.c mem_allo.c mem_allp.c mem_allz.c mem_alzp.c mem_crei.c mem_crep.c mem_extd.c mem_exti.c mem_extp.c mem_fprt.c mem_free.c mem_frei.c mem_gsyp.c mem_gsys.c mem_init.c mem_list.c mem_size.c mem_swap.c mem_swapn.c mem_tesa.c mem_tesp.c mem_test.c mem_util.c mem_vrfy.c mem_xfer.c mem_xfri.c mem_xftd.c mem_zsyf.c mem_zsys.c monitor.c mqx.c mqx_dat.c mqx_fatl.c mqx_gcnt.c mqx_gcpu.c mqx_gini.c mqx_gtad.c mqx_gxit.c mqx_ioc.c mqx_scpu.c mqx_stad.c mqx_sxit.c mqxiinit.c sc_bost.c sc_gprio.c sc_grr.c sc_grrt.c sc_ipq.c sc_numq.c sc_obsel.c sc_spol.c sc_sprio.c sc_srr.c sc_srri.c sc_srrt.c sc_yield.c ta_abort.c ta_build.c ta_creab.c ta_creas.c ta_creat.c ta_dest.c ta_env.c ta_exit.c ta_fp.c ta_getx.c ta_gexit.c ta_gtos.c ta_init.c ta_param.c ta_prem.c ta_prio.c ta_rdy.c ta_rest.c ta_rtos.c ta_setx.c ta_sexit.c ta_sync.c ta_util.c ta_util2.c td_alloc.c td_gerr.c td_get.c td_gid.c td_pid.c td_serr.c td_serrt.c td_sysid.c td_util.c ti_aday.c ti_ahor.c ti_amin.c ti_amsec.c ti_ansec.c ti_apsec.c ti_asec.c ti_ausec.c ti_delay.c ti_delfo.c ti_deli.c ti_delti.c ti_delun.c ti_difda.c ti_diff.c ti_difft.c ti_difhr.c ti_difmn.c ti_difms.c ti_difns.c ti_difps.c ti_difse.c ti_difus.c ti_dque.c ti_dquet.c ti_elaps.c ti_elapt.c ti_from.c ti_get.c ti_gethw.c ti_getns.c ti_getp.c ti_getr.c ti_gett.c ti_getus.c ti_ghwtt.c ti_init.c ti_krnl.c ti_kset.c ti_ksett.c ti_leap.c ti_nxd.c ti_rom.c ti_setr.c ti_sett.c ti_setv.c ti_shwtf.c ti_shwtt.c ti_ti2xd.c ti_to.c ti_xd2ti.c ti_xrom.c titotks.c tkstoti.c tls_gref.c tq_creat.c tq_dest.c tq_func.c tq_test.c tq_tsusp.c tq_util.c
  group PSP Generic:klog
    ../../../mqx/source/klog/: kl_cntrl.c kl_creaa.c kl_creat.c kl_disp.c kl_dispi.c kl_log.c kl_stack.c kl_stsh.c kl_task.c
  group PSP Generic:log
    ../../../mqx/source/log/: lo_comp.c lo_dest.c lo_enabl.c lo_open.c lo_read.c lo_reset.c lo_test.c lo_write.c
  group PSP Generic:lwevent
    ../../../mqx/source/lwevent/: lwe_clr.c lwe_crea.c lwe_dest.c lwe_gets.c lwe_sac.c lwe_set.c lwe_test.c lwe_waif.c lwe_waii.c lwe_waiu.c lwe_watt.c
  group PSP Generic:lwlog
    ../../../mqx/source/lwlog/: lwl_comp.c lwl_crea.c lwl_crei.c lwl_cret.c lwl_dest.c lwl_ena.c lwl_read.c lwl_rst.c lwl_size.c lwl_test.c lwl_wrii.c lwl_writ.c
  group PSP Generic:lwmem
    ../../../mqx/source/lwmem/: lwm_alli.c lwm_allo.c lwm_allp.c lwm_allz.c lwm_alzp.c lwm_crep.c lwm_free.c lwm_gsyp.c lwm_gsys.c lwm_init.c lwm_list.c lwm_setd.c lwm_size.c lwm_test.c lwm_xfer.c lwm_xfri.c lwm_xftd.c lwm_zsyf.c lwm_zsys.c
  group PSP Generic:lwmsg
    ../../../mqx/source/lwmsg/: lwmsgq.c lwmsgq_recv.c lwmsgq_send.c
  group PSP Generic:lwtimer
    ../../../mqx/source/lwtimer/: lwt_cncl.c lwt_cncp.c lwt_test.c lwtimer.c
  group PSP Generic:message
    ../../../mqx/source/message/: ms_alloc.c ms_broad.c ms_close.c ms_comp.c ms_count.c ms_dpool.c ms_free.c ms_id.c ms_note.c ms_open.c ms_openi.c ms_own.c ms_peek.c ms_poll.c ms_pool.c ms_poola.c ms_pooli.c ms_recv.c ms_recvf.c ms_recvi.c ms_recvt.c ms_recvu.c ms_send.c ms_sendb.c ms_sendi.c ms_sendp.c ms_sendq.c ms_sendu.c ms_sopen.c ms_spool.c ms_swap.c ms_tdel.c ms_testp.c ms_testq.c
  group PSP Generic:mutex
    ../../../mqx/source/mutex/: mu_atini.c mu_comp.c mu_dest.c mu_gpol.c mu_gprio.c mu_gprot.c mu_gspin.c mu_init.c mu_lock.c mu_pol.c mu_prio.c mu_prot.c mu_spin.c mu_tdel.c mu_test.c mu_tlock.c mu_ulock.c mu_util.c
  group PSP Generic:name
    ../../../mqx/source/name/: na_abi.c na_add.c na_addi.c na_close.c na_comp.c na_crth.c na_dbi.c na_del.c na_deli.c na_fbi.c na_find.c na_findi.c na_findn.c na_fni.c na_test.c na_testi.c
  group PSP Generic:part
    ../../../mqx/source/part/: pa_alloc.c pa_alloi.c pa_avail.c pa_comp.c pa_creaa.c pa_creai.c pa_creat.c pa_dest.c pa_extnd.c pa_extni.c pa_free.c pa_sallo.c pa_sallz.c pa_tdel.c pa_test.c pa_tx.c pa_util.c pa_zallo.c
  group PSP Generic:queue
    ../../../mqx/source/queue/: qu_deq.c qu_enq.c qu_head.c qu_init.c qu_insrt.c qu_next.c qu_test.c qu_unlnk.c qu_util.c
  group PSP Generic:sem
    ../../../mqx/source/sem/: se_close.c se_comp.c se_creat.c se_dest.c se_fcrt.c se_fdest.c se_fopn.c se_iprio.c se_open.c se_post.c se_tdel.c se_test.c se_util.c se_wait.c se_waitf.c se_waiti.c se_waitt.c se_waitu.c
  group PSP Generic:string
    ../../../mqx/source/string/: str_utos.c strnlen.c
  group PSP Generic:tad
    ../../../mqx/source/tad/: tad.c tad.h
  group PSP Generic:timer
    ../../../mqx/source/timer/: ti_cancl.c ti_comp.c ti_s1afi.c ti_s1aft.c ti_s1ati.c ti_s1att.c ti_spati.c ti_spatt.c ti_spevi.c ti_spevt.c ti_st1af.c ti_st1at.c ti_stpat.c ti_stpev.c ti_task.c ti_tdel.c ti_test.c
  group PSP Generic:watchdog
    ../../../mqx/source/watchdog/: wa_comp.c wa_start.c wa_stop.c wa_strti.c wa_strtt.c wa_tdel.c wa_test.c
  group PSP Cortex
    ../../../mqx/source/psp/cortex/: cortex.c cortex_boot.s dispatch.s int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c mem_copy.c mem_zero.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tixd.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c
  group PSP KINETIS
    ../../../mqx/source/psp/cortex/: kinetis.c kinetis.h kinetis_mpu.c kinetis_mpu.h
  group PSP Include
    ../../../mqx/source/include/: charq.h eds.h eds_prv.h edserial.h edserprv.h event.h evnt_prv.h fio.h fio_prv.h fpio_prv.h io.h io_prv.h io_rev.h ioctl.h ipc.h ipc_pcb.h ipc_pcbv.h ipc_prv.h ipcrtprv.h klog.h log.h log_prv.h lwe_prv.h lwevent.h lwlog.h lwlogprv.h lwmem.h lwmemprv.h lwmsgq.h lwmsgqpr.h lwtimer.h lwtimprv.h mem_prv.h message.h mmu.h mqx.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_macros.h mqx_prv.h mqx_str.h msg_prv.h mutex.h mutx_prv.h name.h name_prv.h part.h part_prv.h pcb.h posix.h sem.h sem_prv.h tim_prv.h timer.h watchdog.h wdog_prv.h
  group Misc Includes
    ../../../mqx/build/: maximum_config.h small_ram_config.h smallest_config.h verif_enabled_config.h
target psp_twrk70f120m Release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: psp_twrk70f120m (library)
  AfterMake: ..\bat\psp_twrk70f120m.bat ..\..\..\lib\twrk70f120m.uv4\psp uv4 release twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
