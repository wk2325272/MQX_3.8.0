# IAR project speaker_twrk70f120m.ewp, settings and files
configuration Int Flash SramData Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lib\twrk70f120m.iar\bsp; ..\..\..\..\..\..\lib\twrk70f120m.iar\psp; ..\..\..\..\..\..\lib\twrk70f120m.iar\bsp\Generated_Code; ..\..\..\..\..\..\lib\twrk70f120m.iar; ..\..\..\..\..\..\lib\twrk70f120m.iar\mfs; ..\..\..\..\..\..\lib\twrk70f120m.iar\usb\host; ..\..\..\..\..\..\lib\twrk70f120m.iar\shell; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk70f120m.srec
  ILINK.IlinkOutputFile: twrk70f120m.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk70f120m.iar\bsp\intflash_sramdata.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash SramData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Flash DDRData Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET; _DEBUG=1
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk70f120m.iar\bsp\intflash_ddrdata.icf
configuration Int Flash DDRData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET; NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: as above
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=1
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk70f120m.iar\bsp\intram.icf
  group MQX Libraries
    ../../../../../../lib/twrk70f120m.iar/bsp/: bsp_twrk70f120m_d.a bsp_twrk70f120m.a
    ../../../../../../lib/twrk70f120m.iar/psp/: psp_twrk70f120m_d.a psp_twrk70f120m.a
    ../../../../../../lib/twrk70f120m.iar/: twrk70f120m_lib.txt
  group MFS Libraries
    ../../../../../../lib/twrk70f120m.iar/mfs/: mfs_twrk70f120m_d.a mfs_twrk70f120m.a
  group USB Host Libraries
    ../../../../../../lib/twrk70f120m.iar/usb/host/: usb_hdk_twrk70f120m_d.a usb_classes.c usb_hdk_twrk70f120m.a
  group Shell Libraries
    ../../../../../../lib/twrk70f120m.iar/shell/: shell_twrk70f120m_d.a shell_twrk70f120m.a
  group Source
    ../: audio_speaker.c audio_speaker.h audio_timer.c audio_timer.h sh_audio.c sh_audio.h usb_classes.h wav.c wav.h
