# IAR project usb_ddk_twrk70f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.PreInclude: ..\..\..\..\mqx\source\psp\cortex\psp_abi.h
  ICCARM.CCIncludePath2: ..\..\..\..\lib\twrk70f120m.iar\bsp\Generated_Code; ..\..\..\..\lib\twrk70f120m.iar\bsp; ..\..\..\..\lib\twrk70f120m.iar\psp; ..\..\..\..\lib\twrk70f120m.iar; ..\..\source\classes\include; ..\..\source\include\rtos; ..\..\source\include\usbfs; ..\..\source\include; ..\..\..\..\config\twrk70f120m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "..\bat\usb_ddk_usbfs.bat" "..\..\..\..\lib\twrk70f120m.iar\usb\device\usb_ddk_twrk70f120m_d.a" IAR
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; NDEBUG
  ICCARM.CCOptLevel: 3
  postbuild: "..\bat\usb_ddk_usbfs.bat" "..\..\..\..\lib\twrk70f120m.iar\usb\device\usb_ddk_twrk70f120m.a" IAR
  ILINK.IlinkOutputFile: libgeneric.out
  group twrk70f120m Config in lib
    ../../../../lib/twrk70f120m.iar/: twrk70f120m_lib.txt
  group USB Class Drivers/audio
    ../../source/classes/audio/: usb_audio.c
    ../../source/classes/include/: usb_audio.h
  group USB Class Drivers/cdc
    ../../source/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
    ../../source/classes/include/: usb_cdc.h usb_cdc_pstn.h
  group USB Class Drivers/usb_class
    ../../source/classes/common/: usb_class.c
    ../../source/classes/include/: usb_class.h
  group USB Class Drivers/framework
    ../../source/classes/common/: usb_framework.c
    ../../source/classes/include/: usb_framework.h
  group USB Class Drivers/hid
    ../../source/classes/hid/: usb_hid.c
    ../../source/classes/include/: usb_hid.h
  group USB Class Drivers/msd
    ../../source/classes/include/: usb_msc.h usb_msc_scsi.h
    ../../source/classes/msd/: usb_msc.c usb_msc_scsi.c
  group USB Class Drivers/phdc
    ../../source/classes/include/: usb_phdc.h
    ../../source/classes/phdc/: usb_phdc.c
  group USB Device/source
    ../../source/device/: dev_cncl.c dev_ep_deinit.c dev_main.c dev_recv.c dev_send.c dev_shut.c dev_utl.c
  group USB Device/os
    ../../source/include/rtos/: mqx_dev.h
    ../../source/rtos/mqx/: usbinst.c
  group USB Device/include
    ../../source/classes/include/: usb_stack_config.h
    ../../source/include/: dev_cnfg.h devapi.h types.h usb.h usbprv.h
  group USB Low Level Driver
    ../../source/device/usbfs/: callback_usbfs.c usbfs_dev_main.c
    ../../source/include/usbfs/: usbfs_dev_main.h usbprv_fs.h
