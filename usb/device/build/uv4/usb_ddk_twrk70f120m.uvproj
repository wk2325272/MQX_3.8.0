# Keil uVision project usb_ddk_twrk70f120m.uvproj, settings and files
target usb_ddk_twrk70f120m Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: usb_ddk_twrk70f120m_d (library)
  AfterMake: ..\bat\usb_ddk_usbfs.bat ..\..\..\..\lib\twrk70f120m.uv4\usb\device uv4 debug twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c include: ..\..\..\..\lib\twrk70f120m.uv4\bsp\Generated_Code;..\..\..\..\lib\twrk70f120m.uv4\bsp;..\..\..\..\lib\twrk70f120m.uv4\psp;..\..\..\..\lib\twrk70f120m.uv4;..\..\source\classes\include;..\..\source\include\rtos;..\..\source\include\usbfs;..\..\source\include
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
  group twrk70f120m Config in lib
    ../../../../lib/twrk70f120m.uv4/: twrk70f120m_lib.txt
  group USB Class Drivers:audio
    ../../../../usb/device/source/classes/audio/: usb_audio.c
    ../../../../usb/device/source/classes/include/: usb_audio.h
  group USB Class Drivers:cdc
    ../../../../usb/device/source/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
    ../../../../usb/device/source/classes/include/: usb_cdc.h usb_cdc_pstn.h
  group USB Class Drivers:usb_class
    ../../../../usb/device/source/classes/common/: usb_class.c
    ../../../../usb/device/source/classes/include/: usb_class.h
  group USB Class Drivers:framework
    ../../../../usb/device/source/classes/common/: usb_framework.c
    ../../../../usb/device/source/classes/include/: usb_framework.h
  group USB Class Drivers:hid
    ../../../../usb/device/source/classes/hid/: usb_hid.c
    ../../../../usb/device/source/classes/include/: usb_hid.h
  group USB Class Drivers:msd
    ../../../../usb/device/source/classes/include/: usb_msc.h usb_msc_scsi.h
    ../../../../usb/device/source/classes/msd/: usb_msc.c usb_msc_scsi.c
  group USB Class Drivers:phdc
    ../../../../usb/device/source/classes/include/: usb_phdc.h
    ../../../../usb/device/source/classes/phdc/: usb_phdc.c
  group USB Device:source
    ../../../../usb/device/source/device/: dev_cncl.c dev_ep_deinit.c dev_main.c dev_recv.c dev_send.c dev_shut.c dev_utl.c
  group USB Low Level Driver
    ../../../../usb/device/source/device/usbfs/: callback_usbfs.c usbfs_dev_main.c
    ../../../../usb/device/source/include/usbfs/: usbfs_dev_main.h usbprv_fs.h
  group USB Device:os
    ../../../../usb/device/source/include/rtos/: mqx_dev.h
    ../../../../usb/device/source/rtos/mqx/: usbinst.c
  group USB Device:include
    ../../../../usb/device/source/classes/include/: usb_stack_config.h
    ../../../../usb/device/source/include/: dev_cnfg.h devapi.h types.h usb.h usbprv.h
target usb_ddk_twrk70f120m Release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: usb_ddk_twrk70f120m (library)
  AfterMake: ..\bat\usb_ddk_usbfs.bat ..\..\..\..\lib\twrk70f120m.uv4\usb\device uv4 release twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
