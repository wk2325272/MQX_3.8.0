# Keil uVision project shell_twrk70f120m.uvproj, settings and files
target shell_twrk70f120m Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: shell_twrk70f120m_d (library)
  AfterMake: ..\bat\shell.bat ..\..\..\lib\twrk70f120m.uv4\shell uv4 debug twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c include: ..\..\..\lib\twrk70f120m.uv4\bsp\Generated_Code;..\..\..\lib\twrk70f120m.uv4\bsp;..\..\..\lib\twrk70f120m.uv4\mfs;..\..\..\lib\twrk70f120m.uv4\psp;..\..\..\lib\twrk70f120m.uv4\rtcs;..\..\..\lib\twrk70f120m.uv4;..\..\source\include
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
  group twrk70f120m Config in lib
    ../../../lib/twrk70f120m.uv4/: twrk70f120m_lib.txt
  group Shell Source:MFS
    ../../../shell/source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
  group Shell Source:MQX
    ../../../shell/source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
  group Shell Source:RTCS
    ../../../shell/source/rtcs/: sh_arpdisp.c sh_clock.c sh_echod.c sh_eds.c sh_enet.c sh_exec.c sh_ftpc.c sh_ftpd.c sh_gate.c sh_getroute.c sh_ghbn.c sh_ipconfig.c sh_iwconfig.c sh_load.c sh_nat.c sh_nstat.c sh_ping.c sh_rtcs.c sh_sendto.c sh_snmpd.c sh_tftp.c sh_tftpd.c sh_tnet.c sh_tnetd.c
  group Shell Source:Shell
    ../../../shell/source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
  group Shell Include
    ../../../shell/source/include/: sh_enet.h sh_mfs.h sh_prv.h sh_rtcs.h shell.h
target shell_twrk70f120m Release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: shell_twrk70f120m (library)
  AfterMake: ..\bat\shell.bat ..\..\..\lib\twrk70f120m.uv4\shell uv4 release twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
