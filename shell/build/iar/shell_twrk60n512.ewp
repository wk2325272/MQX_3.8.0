# IAR project shell_twrk60n512.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.PreInclude: ..\..\..\mqx\source\psp\cortex\psp_abi.h
  ICCARM.CCIncludePath2: ..\..\..\lib\twrk60n512.iar\bsp\Generated_Code; ..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\lib\twrk60n512.iar\mfs; ..\..\..\lib\twrk60n512.iar\psp; ..\..\..\lib\twrk60n512.iar\rtcs; ..\..\..\lib\twrk60n512.iar; ..\..\source\include; ..\..\..\config\twrk60n512
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "..\bat\shell.bat" "..\..\..\lib\twrk60n512.iar\shell\shell_twrk60n512_d.a" IAR
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; NDEBUG
  ICCARM.CCOptLevel: 3
  postbuild: "..\bat\shell.bat" "..\..\..\lib\twrk60n512.iar\shell\shell_twrk60n512.a" IAR
  ILINK.IlinkOutputFile: libgeneric.out
  group Shell Include
    ../../source/include/: sh_enet.h sh_mfs.h sh_prv.h sh_rtcs.h shell.h
  group Shell Source/MFS
    ../../source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_df_driver.c sh_df_file.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_read_wk.c sh_readtest.c sh_rename.c sh_rmdir.c sh_search_file.c sh_search_file_1.c sh_type.c sh_update.c sh_write.c sh_write_binary.c sh_write_buf.c sh_writetest.c
  group Shell Source/MQX
    ../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
  group Shell Source/RTCS
    ../../source/rtcs/: sh_arpdisp.c sh_clock.c sh_echod.c sh_eds.c sh_enet.c sh_exec.c sh_ftpc.c sh_ftpd.c sh_gate.c sh_getroute.c sh_ghbn.c sh_ipconfig.c sh_iwconfig.c sh_load.c sh_nat.c sh_nstat.c sh_ping.c sh_rtcs.c sh_sendto.c sh_snmpd.c sh_tftp.c sh_tftpd.c sh_tnet.c sh_tnetd.c
  group Shell Source/Shell
    ../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
  group twrk60n512 Config in lib
    ../../../lib/twrk60n512.iar/: twrk60n512_lib.txt
