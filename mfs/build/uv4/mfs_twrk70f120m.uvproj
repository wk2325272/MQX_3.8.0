# Keil uVision project mfs_twrk70f120m.uvproj, settings and files
target mfs_twrk70f120m Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: mfs_twrk70f120m_d (library)
  AfterMake: ..\bat\mfs.bat ..\..\..\lib\twrk70f120m.uv4\mfs uv4 debug twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c include: ..\..\..\lib\twrk70f120m.uv4\bsp\Generated_code;..\..\..\lib\twrk70f120m.uv4\bsp;..\..\..\lib\twrk70f120m.uv4\psp;..\..\..\lib\twrk70f120m.uv4;..\..\..\mqx\source\include;..\..\source\include
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
  group twrk70f120m Config in lib
    ../../../lib/twrk70f120m.uv4/: twrk70f120m_lib.txt
  group MFS Source
    ../../../mfs/source/generic/: dir_read.c mfs_attribute.c mfs_cluster.c mfs_create.c mfs_data_sector.c mfs_delete.c mfs_dir_entry.c mfs_directory.c mfs_fat.c mfs_format.c mfs_handle.c mfs_init.c mfs_lfn.c mfs_misc.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_valdev.c mfs_write.c part_mgr.c
  group MFS Include
    ../../../mfs/source/include/: mfs.h mfs_cnfg.h mfs_prv.h mfs_rev.h part_mgr.h
target mfs_twrk70f120m Release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: mfs_twrk70f120m (library)
  AfterMake: ..\bat\mfs.bat ..\..\..\lib\twrk70f120m.uv4\mfs uv4 release twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
