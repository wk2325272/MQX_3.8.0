# Keil uVision project rtcs_twrk70f120m.uvproj, settings and files
target rtcs_twrk70f120m Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: rtcs_twrk70f120m_d (library)
  AfterMake: ..\bat\rtcs.bat ..\..\..\lib\twrk70f120m.uv4\rtcs uv4 debug twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c include: ..\..\..\lib\twrk70f120m.uv4\bsp\Generated_Code;..\..\..\lib\twrk70f120m.uv4\bsp;..\..\..\lib\twrk70f120m.uv4\mfs;..\..\..\lib\twrk70f120m.uv4\psp;..\..\..\lib\twrk70f120m.uv4;..\..\..\mfs\source\include;..\..\..\mqx\source\include;..\..\source\httpd;..\..\source\include
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
  group twrk70f120m Config in lib
    ../../../lib/twrk70f120m.uv4/: twrk70f120m_lib.txt
  group RTCS Source:apps
    ../../../rtcs/source/apps/: binfile.c coff.c dhcpsrv.c echosrv.c eds.c ftpc.c ftpc_cmd.c ftpclnt.c ftpd.c ftpd_cmd.c ftpd_msg.c loadtb.c loadtc.c loadts.c resolver.c rtcsload.c rtcssh.c sntp.c sockio.c srec32.c srecord.c telnet.c telnetio.c telnsrv.c tftp.c tftpacc.c tftpsrv.c tftputil.c
  group RTCS Source:httpd
    ../../../rtcs/source/httpd/: httpd.c httpd.h httpd_cnfg.h httpd_mqx.h httpd_poll.c httpd_prv.h httpd_supp.c httpd_supp.h httpd_task.c httpd_types.h httpd_wrapper.h
  group RTCS Source:if
    ../../../rtcs/source/if/: arpcmd.c dnshosts.c dnsinit.c dnsutil.c ghbname.c ifadd.c ifbootp.c ifdhcp.c ifdns.c ifppp.c ifrem.c ifstat.c iftraps.c iftunnel.c inet.c ipcfg.c iwcfg.c ping.c rtcs.c rtcscmd.c rtcsdela.c rtcsglob.c rtcshost.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sdgram.c select.c sockutil.c soigmp.c soip.c solink.c sosel0.c sosel1.c soselall.c soselset.c sosock.c sotcp.c soudp.c sstream.c
  group RTCS Source:ipc_udp
    ../../../rtcs/source/ipc_udp/: ipc_udp.c
  group RTCS Source:media
    ../../../rtcs/source/media/: arp.c arpinit.c ip-e.c ipcp.c ipcpfsm.c proxyarp.c
  group RTCS Source:os
    ../../../rtcs/source/os/mqx25x/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group RTCS Source:ppp
    ../../../rtcs/source/ppp/: ccp.c chap.c gen16.c genmd5.c hdlcio.c hdlcio2.c lcp.c lcpif.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group RTCS Source:rpc
    ../../../rtcs/source/rpc/: authnone.c clnterr.c clntpmap.c clnttcp.c clntudp.c portmap.c svcauth.c svcpmap.c svcreply.c svcrun.c svctcp.c svcudp.c
  group RTCS Source:snmp
    ../../../rtcs/source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group RTCS Source:tcpip
    ../../../rtcs/source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_reasm.c ipif_add.c ipif_rem.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcpip.c ticker.c timer.c udp.c
  group RTCS Source:xdr
    ../../../rtcs/source/xdr/: xdr.c xdrmem.c xdrpmap.c xdrrec.c xdrrpc.c
  group RTCS Include
    ../../../rtcs/source/include/: arp.h arp_prv.h arpif.h asn1.h auth.h bootp.h ccp.h chap.h checksum.h clnt.h dhcp.h dhcp_prv.h dhcpsrv.h dhcpuprv.h dns.h fcs16.h ftp.h ftpc.h ftpd.h ftpd_msg.h icmp.h icmp_prv.h igmp.h ip-e.h ip.h ip_prv.h ipc_udp.h ipc_udp_prv.h ipcfg.h ipcfg_prv.h ipcp.h ipradix.h iptunnel.h iwcfg.h lcp.h md5.h nat.h nat_prv.h nat_session.h natvers.h pap.h pmap.h pmapif.h ppp.h ppp_prv.h pppfsm.h ppphdlc.h rip.h rip_prv.h route.h rpcmsg.h rpctypes.h rtcs.h rtcs25x.h rtcs_in.h rtcs_prv.h rtcscfg.h rtcshdlc.h rtcslog.h rtcspcb.h rtcsrpc.h rtcsrtos.h rtcstime.h rtcsvers.h select.h snmp.h snmpcfg.h socket.h svc.h svcauth.h tcp.h tcp_prv.h tcpip.h telnet.h tftp.h ticker.h udp.h udp_prv.h xdr.h
target rtcs_twrk70f120m Release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: rtcs_twrk70f120m (library)
  AfterMake: ..\bat\rtcs.bat ..\..\..\lib\twrk70f120m.uv4\rtcs uv4 release twrk70f120m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk70f120m.uv4\mqx\intflash.scf
